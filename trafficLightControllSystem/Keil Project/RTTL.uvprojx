# Keil uVision project RTTL.uvprojx, settings and files
target RTTL T1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTTL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries\CMSIS\Includes;.\Libraries\RoboTraffic Traffic Lights Library;.\Libraries\Standard Peripheral Library\Includes
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Sources
    ./Sources/: main.c
  group Includes
    ./Libraries/Standard Peripheral Library/Includes/: stm32f0xx.h
  group SPL
    ./Libraries/Standard Peripheral Library/Sources/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c system_stm32f0xx.c
    ./Libraries/Standard Peripheral Library/Asmbls/: startup_stm32f030x6.s
  group RTTLL
    ./Libraries/RoboTraffic Traffic Lights Library/: RTTLL.h
